## embedded/imager/Config.in
```kconfig
source "$BR2_EXTERNAL_IMAGER_PATH/package/aliro-imager/Config.in"
source "$BR2_EXTERNAL_IMAGER_PATH/package/aliro-firmware-custom/Config.in"
```
